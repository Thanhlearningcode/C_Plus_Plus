# Keil uVision project UART.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\PWM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: UART.s main.c HSC04.c HSCR04.h UART_DMA.c UART_DMA.h ENCODER.h ENCODER.c PWM.h Car_Engine.c Car_Engine.h Timer.c Timer.h
    ../PWM/: PWM.s
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
